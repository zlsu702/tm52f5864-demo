# Keil uVision project TM52F5864.uvproj, settings and files
target Target 1 (MCS-51)
  device: TM52F5864 tenx
  cpu: IRAM(0-0xFF) CLOCK(16000000) XRAM(0xFD00-0xFFFF)
  output: TM52F5864 +hex
  AfterMake: .\_Make_TM52F5864\run.bat
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src
  group Source Group 1
    ./: STARTUP_TENX52.A51
    ./src/: main.c alarm.c Function.c gxhtv4.c Isr.c keycode.c Led.c REFRESH.c rf.c Scankey.c SysInit.c time.c
